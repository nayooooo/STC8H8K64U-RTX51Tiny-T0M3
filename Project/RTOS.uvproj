# Keil uVision project RTOS.uvproj, settings and files
target FLASH (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: RTOS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Fwlib;..\User;..\RTOS;..\Hardware\LED
  group FWLIB
    ../Fwlib/: delay.c GPIO.c
  group USER
    ../User/: main.c
  group RTOS
    ../RTOS/: Conf_tny.A51 RTX51TNY.LIB
  group HARDWARE
    ../Hardware/LED/: led.c
